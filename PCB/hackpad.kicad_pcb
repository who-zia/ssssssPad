# Repository who-zia/ssssssPad

File README.md:

## "sssssss"-Pad

> "sssssss"-Pad will never "sssssss" at you and leave. It will infact accompany you at your worsts. ~~*(yes people like this exist)*~~

---

### What can it do and what is special about it?

"sssssss"-Pad is a macropad on which you can play snake and distract you for a bit ~~*from your messed up love-life*~~ .

---
### Picture*ssssss*

| Description | Picture |
| --- | ----------- |
| case |  |
| pcb design |  |
| pcb in 3d |  |
| schematic |  |

---

### BOM

here's everything needed to make this "sssssss"-Pad :-
<ul>
  <li>1x SEEED Xiao RP2040</li>
  <li>4x MX-Style switches</li>
  <li>4x Blank DSA Keycaps</li>
  <li>4x M3x16 Bolts</li>
  <li>4x M3 Heatset Inserts</li>
  <li>1x 0.91 inch OLED display </li>
  <li>1x PCB</li>
  <li>1x 3D Case</li>
</ul>

---

## KiCad design PCB/hackpad.kicad_pcb

Parts:
SW1, SW2, SW3, SW4: SW_Push; SW_Cherry_MX_1.00u_PCB
U1: MOUDLE-SEEEDUINO-XIAO; XIAO-Generic-Hybrid-14P-2.54-21X17.8MM
U2: ER_OLEDM0.91_1x-I2C

Connections:
GND: SW1.2, SW2.2, SW3.2, SW4.2, U1.13 (GND), U2.1 (GND)
unnamed: U1.12 (3V3), U2.2 (VCC)
unnamed: SW2.1, U1.10 (PA5_A9_D9_MISO)
unnamed: SW1.1, U1.11 (PA6_A10_D10_MOSI)
unnamed: SW3.1, U1.9 (PA7_A8_D8_SCK)
unnamed: U1.5 (PA8_A4_D4_SDA), U2.4 (SDA)
unnamed: U1.6 (PA9_A5_D5_SCL), U2.3 (SCL)
unnamed: SW4.1, U1.8 (PB09_A7_D7_RX)

Board: 2 copper layers, 67.0 x 62.0 mm, 6 parts (1 on the bottom side), 8 nets.

## Commit log

2026-06-23 removed redundant folder
2026-06-23 changed oled
2026-06-25 finalized the README
2026-06-27 removed desktop.ini
2026-06-27 deleted desktop.ini
